Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-09T14:22:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 09 14:22:01 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{011FC247-4C15-45D6-B66F-AB9EA37D47A5}\ifc * Database version: 5507 * Database creation date: Mon Aug 09 14:22:00 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 09 14:22:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 09 14:22:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 5665 Shower faucet, 5665(2021):5665 Shower faucet:343785
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 82.539 mm; NominalHeight: 100.184 mm; NominalWidth: 289.137 mm
Type - General - Author: BIMstone; BIMObjectName: 5665(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 21/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150098543; EN Standard: EN 1111; LVI Number: 6310885; Noise Class: I (ISO 3822); Noise Class 02ls: I (ISO 3822); RSK Number: 8386867
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5665; Catalog Drawing URL: http://static.oras.com/catdrw/5665; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/5665; FDV Document URL: http://www.oras.com/datasheet/5665/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5665; Group: Shower faucets; Long Marketing: Thermostatic shower faucet with ergonomic flow handles. Temperature handle equipped with safety stop at 38°C. Volume handle with EcoFlow control. The faucet includes litter filters and non-return valves.; Manufacturer: Oras; Market: INT;FIN;SWE; Model: 5665 Shower faucet; Name_en: 5665 Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 294 x 164 x 83; Package Weight: 2.181 kg; Product Code: 5665; Product Datasheet: http://www.oras.com/datasheet/5665/en; Product Family: Oras Clinica; Product Image URL: http://static.oras.com/image/5665; Product URL: http://static.oras.com/5665; Technical DataSheet URL: http://www.oras.com/datasheet/5665/en; Type Name: 5665 Shower faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Connection: DirectConnection; Connection Size: G3/4; Flow Rate At 300kPa: 0.00918181 m3/s; Installation and Maintenance: http://static.oras.com/manual/5665; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle;; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part;;Non-return valve(s);Litter filter(s); Not Included: WithoutCouplings; Spare Parts: http://static.oras.com/sp/5665; Temperature Adjustments: THERMO COOL
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5665(2021); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5665; Name: 5665 Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 280x190x100 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0527012 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00173533 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5665(2021): 5665 Shower faucet; Family and Type: 5665(2021): 5665 Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5665(2021): 5665 Shower faucet; Type Id: 5665(2021): 5665 Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
